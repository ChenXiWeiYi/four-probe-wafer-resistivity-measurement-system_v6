# Keil uVision project EightChannel_Switching.uvprojx, settings and files
target EightChannel_Switching (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\OBJ;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\TIMER;..\GPIO;..\EXTI;..\ADC;..\DAC;..\SPI;..\COMM;..\CHANNEL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c Measure.c Control_Current_Value.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_ll_fsmc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group TIMER
    ../TIMER/: TIM_Init.c TIM2_Init.c
  group GPIO
    ../GPIO/: GPIO_Init.c HC595_GPIO_Init.c KeyBoardKey_GPIO_Init.c KeyBoardLED_GPIO_Init.c ADC_GPIO_Init.c DAC_GPIO_Init.c CCS2GND_GPIO_Init.c LTC6373_GPIO_Init.c MeasureDirection_GPIO_Init.c
  group EXTI
    ../EXTI/: EXTI_Init.c EXTI1_Interrupt.c EXTI4_Interrupt.c EXTI6_Interrupt.c EXTI2_Interrupt.c EXTI13_Interrupt.c EXTI14_Interrupt.c
  group ADC
    ../ADC/: Function_ADC_Init.c Function_ADC_Read.c Function_ADC_Gain.c
  group DAC
    ../DAC/: Function_DAC.c
  group SPI
    ../SPI/: SPI_Init.c SPI1_Init.c SPI2_Init.c SPI3_Init.c
  group COMM
    ../COMM/: Answer_Handler.c Command_Handler.c Process_USART1.c Protocol_CalcCRC16.c Protocol_SendPacket.c USART.c
  group CHANNEL
    ../CHANNEL/: Auto_Select_Channel.c Set_Current_Position.c Set_Voltmeter1_Range.c Set_Voltmeter2_Range.c
